# Keil uVision project 2026706296.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x0800D000,0x05A000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: E:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=.\output\Project.bin .\output\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Function;..\HardWare\LED;..\HardWare\KEY;..\HardWare\USART;..\HardWare\OLED;..\HardWare\STORAGE;..\HardWare\ANALOG;..\HardWare\RTC;..\HardWare\POWER;..\HardWare\BOOTLOADER;..\HardWare\GD25QXX;..\HardWare\GD30AD3344;..\HardWare\SDIO;..\CMSIS;..\CMSIS\GD\GD32F4xx\Include;..\Library\Third_Party\fat_fs\inc
  memory RVCT4: ROM 0x800d000 size 0x5a000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../Library/Third_Party/fat_fs/src/: diskio.c ff.c
    ../Library/Third_Party/fat_fs/src/option/: ccsbcs.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group HardWare
    ../HardWare/LED/: bsp_led.c
    ../HardWare/KEY/: bsp_key.c
    ../HardWare/USART/: bsp_usart.c
    ../HardWare/OLED/: bsp_oled.c oled.c
    ../HardWare/STORAGE/: bsp_storage.c
    ../HardWare/ANALOG/: bsp_analog.c
    ../HardWare/RTC/: bsp_rtc.c
    ../HardWare/POWER/: bsp_power.c
    ../HardWare/BOOTLOADER/: bootloader_port.c
    ../HardWare/GD25QXX/: gd25qxx.c smartfs_port.c
    ../HardWare/SDIO/: sdio_sdcard.c
    ../HardWare/GD30AD3344/: gd30ad3344.c
  group Function
    ../Function/: btn_app.c led_app.c oled_app.c usart_app.c sd_app.c rtc_app.c adc_app.c scheduler.c uart_ota_app.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c boot_app_config.c boot_app_config.h
    ../HeaderFiles/: system_all.h
