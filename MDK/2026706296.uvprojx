# Keil uVision project 2026706296.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x0800D000,0x05A000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: E:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=.\output\Project.bin .\output\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Libraries\Include;..\USER;..\USER\App;..\USER\Driver;..\Driver\CMSIS;..\Driver\CMSIS\GD\GD32F4xx\Include;..\USER\Component\oled;..\USER\Component\gd25qxx;..\USER\Component\sdio;..\USER\Component\gd30ad3344;..\USER\Component\fatfs;..\PACK\perf_counter-2.5.4
  memory RVCT4: ROM 0x800d000 size 0x5a000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Peripherals
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Libraries/: startup_gd32f450_470.s
  group CMSIS
    ../Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Utilities
    ../PACK/perf_counter-2.5.4/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
  group User/Driver
    ../USER/Driver/: bsp_led.c bsp_key.c bsp_usart.c bsp_oled.c bsp_storage.c bsp_analog.c bsp_rtc.c bsp_power.c bootloader_port.c
  group User/Components/gd25qxx
    ../USER/Component/gd25qxx/: gd25qxx.c smartfs_port.c
  group User/Components/oled
    ../USER/Component/oled/: oled.c
  group User/Components/sdio
    ../USER/Component/sdio/: sdio_sdcard.c
  group User/Components/gd30ad3344
    ../USER/Component/gd30ad3344/: gd30ad3344.c
  group User/Components/fatfs
    ../USER/Component/fatfs/: diskio.c ff.c
    ../USER/Component/fatfs/option/: ccsbcs.c
  group User/APP
    ../USER/App/: btn_app.c led_app.c oled_app.c usart_app.c sd_app.c rtc_app.c adc_app.c scheduler.c uart_ota_app.c
  group User
    ../USER/: gd32f4xx_it.c main.c systick.c boot_app_config.c system_all.h boot_app_config.h
